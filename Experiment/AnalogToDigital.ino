/*
Analog to digital conversion
*/

bool send_signal = false;
bool is_flag_sample = false;

void setup() {
  // initialise with baudrate
  Serial.begin(9600);
  // send one byte to check connection
  Serial.write(0);
}

void loop() {
  // read from analog pin 0
  int analogValue = analogRead(A0); 
  
  // check whether this is a flag sample (indicates
  // the start or end of an information stream)
  if ((analogValue > 633) && (analogValue < 636))
  {
    is_flag_sample = true;
  }
  else
  {
    is_flag_sample = false;
  }
  
  if (is_flag_sample == true)
  {
    // start signal of stream
    if (send_signal == false)
    {
    send_signal = true;
    }
    // end signal of stream
    else if (send_signal == true)
    {
      send_signal = false;
    }
  }
  
  if (send_signal == true)
  {
    // send to serial port
    Serial.println(analogValue);
  }
}
